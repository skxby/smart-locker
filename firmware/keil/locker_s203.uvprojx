# Keil uVision project locker_s203.uvprojx, settings and files
target S203_hsi16 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: locker_s203 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F407xx,USE_HAL_DRIVER,__MICROLIB,LFS_NO_MALLOC,LFS_NO_ASSERT,LFS_NO_DEBUG,LFS_NO_WARN,LFS_NO_ERROR,LOCKER_S202,LOCKER_S203
  c include: ..\config;..\third_party\stm32f4\cmsis;..\third_party\stm32f4\hal\Inc;..\third_party\freertos\include;..\third_party\freertos\portable\RVDS\ARM_CM4F;..\third_party\littlefs;..\board;..\drivers;..\tasks;..\transport;..\..\contracts\include;..\..\host\device\include
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f407vg.sct
  group S2-03 UART communication
    ../app/: main.c
    ../board/: board.c peripherals.c
    ../hal/: timebase_tim6.c
    ../third_party/stm32f4/cmsis/: system_stm32f4xx.c startup_stm32f407xx.s
    ../third_party/stm32f4/hal/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_iwdg.c
    ../third_party/freertos/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c croutine.c
    ../third_party/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../third_party/freertos/portable/MemMang/: heap_4.c
    ../third_party/littlefs/: lfs.c lfs_util.c
    ../drivers/: inputs.c rc522.c
    ../tasks/: communication.c
    ../transport/: transport.c
    ../../host/device/src/: wire.c codec.c
target S203_hse8_168 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: locker_s203 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F407xx,USE_HAL_DRIVER,__MICROLIB,LFS_NO_MALLOC,LFS_NO_ASSERT,LFS_NO_DEBUG,LFS_NO_WARN,LFS_NO_ERROR,ENV_HSE8_168,LOCKER_S202,LOCKER_S203
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f407vg.sct
